# Keil uVision project my51Car.uvproj, settings and files
target MPU6050 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: my51Car +hex
  c flags: Optimize=8 SizeSpeed=1
  group Master
    ./: 00main.c
  group APP
    ./: 01public.c 02st7565.c 04mpu6050.c
